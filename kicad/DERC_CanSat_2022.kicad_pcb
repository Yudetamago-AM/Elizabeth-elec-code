# Repository Yudetamago-AM/Elizabeth-elec-code

File README.md:

# CanSat2022

この文書をソフト全体のドキュメントとして扱えるようにしたいなーと思っています．

## 注意
プログラムを書く前に，VS Codeのソース管理タブ→三点リーダ，レポジトリからプルすること．

## はじめに

ここでは，第18回能代宇宙イベントに向けた缶サットのプログラムを開発する．なお，われわれの缶サットの成功基準は下のように定められている．

| 種別 | 基準 |
| ---- | ---- |
| Minimum Success | 機体の損傷無く着地し，パラシュートを切り離す．制御履歴を保存する． |
| Full Success | 正常な動作を開始し，ゴール5m圏内に近づく． |
| Extra Success | ゴール0mまで近づき停止する． |

## 本番の流れ

1. 前日にゴール場所の座標を調べる．
1. 当日投下前に，動作タイマーをセットする．
1. 投下→自動誘導
この中で使うプログラムをここで書いていく．

## 回路について

### 搭載部品

主要な搭載部品は以下の通りである．

| 役割 | 型番 | 参考になるサイト |
| --- | --- | --- |
| マイコン | ATmega328P | <https://ht-deko.com/arduino/atmega328p.html> |
| GNSS | AE-GYSFDMAXB | <https://github.com/askn37/GPS_MTK333X> |
| 9軸センサー | AE-BNO055-BO | <https://learn.adafruit.com/adafruit-bno055-absolute-orientation-sensor/arduino-code> |
| 超音波距離センサー | HC-SR04 | <https://akizukidenshi.com/catalog/g/gM-11009/> |
| microSD | AE-microSD-LLCNV | <https://akizukidenshi.com/catalog/g/gK-14015/> |
| モータードライバ | TB67H450FNG | <https://www.marutsu.co.jp/contents/shop/marutsu/datasheet/TB67H450FNG.pdf> |

なお，マイコンと部品間のピンアサインは，PinAssign.hを参照．

## 実装上の注意

メモリが限られている（全体で2048バイト，SDカードのバッファ用に512バイト，Arduino Bootloaderにいくらか持って行かれている）ため，メモリを節約してプログラムを書くこと．

## 必要なライブラリ

### モーター制御

がんばって書く，TB67H450FNGを用いたPWM定電流制御．電流値は，基板上の抵抗で決める．
前進，後進，ブレーキ，超信地旋回ができるように．早さはPWMで指定して呼び出す感じにする．
PWMは100以上くらいじゃないと，うまく回らない印象（実際に使うモーターでなくて，マブチモーターだけど）．あと，回り始めに一気に電流が必要そうなので，コンデンサの容量増やしたりした方が良いかも．

### GNSS情報取得

<https://github.com/askn37/GPS_MTK333X>
このなんだか便利（シンプル）そうなライブラリが使えそうです．なので，ちょちょっとメイン制御の方に書くのみで大丈夫と思います．

### ログ記録

AE-microSD-LLCNVを使う．がんばって書く．そんなに大変そうじゃ無い．

### 9軸

方位，加速度などを取得する．秋月のBNO055採用のため，Adafruitのライブラリが使える．
方位の値が安定しない問題があったが，SDAに2.2K, SCLに3.3Kのプルアップ抵抗を付けることで解決する（詳細はAdafruit BNO055のFAQを参照）．
→組み立て時に追加する．
また，信頼できる値は，bno.getCalibration(引数)の相当する引数の値が，0でない時である．

## メインプログラム

### メイン制御 [Main.ino]

各Seqをそれぞれ呼び出す．

### Landing()

- 着地判定
9軸の加速度の大きさ，（GPSの速度の大きさを見る），念のためタイマーも入れておく．
- パラシュートに絡まないようにする（すこし前に進む？）．
- ニクロム線カット
PIN_NICHROME(中身はanalog pin 7(PD7))をHIGHにすればオンになるはず．

#### ニクロム線溶断について

実験してみたところ，ニクロム線が短すぎると，バッテリの短絡防止回路がうごいて，モーター・ニクロム線系統の電源が落ちてしまう．
ニクロム線を長めに取る（5Ω分くらい）と，うまくいく（抵抗を付けるのもありかも→要実験）．
溶断にかかる時間は，ある程度テンションをかけた状態で，3秒ほどであった．
このため，ニクロム線の長さにもよるが，5秒ほど電流を流した方が良いかと思う．

### GuideGPS()

- GPSで精度限界まで誘導する
上に上げたライブラリを叩いて今の座標とか取得して良い感じに計算して誘導すれば良いはず．

今更気付いたのだが，Arduinoのfloat型は"the total number of digits"で6-7桁しか精度がないため，目的地への角度・距離の計算結果には十分な精度がない（というのも，緯度・経度は小数点以下6桁でおよそ10cm精度が出るためであり，われわれにはこのくらい必要だからである）．
困ったので，GPSの座標は固定小数点として扱う．

### GuideDIST()

- 超音波距離センサーで0mまで誘導する

われわれはついてるはずなので，カラーコーン±50cmくらいまでGPSで誘導できるはず．その後，超信地旋回をしながら，カラーコーンの位置と距離を認識して，その距離分進む．

### Goal()

ゴール判定をする．ゴールと判定したら，プログラム終了！
GuideDIST()でむしろ明後日の方向へ行ってしまっているようならば，もういちどGPSで誘導して終わりにする．

### Distance()

超音波距離センサーをつかって，目の前の物体までの距離をcmで返す．
（一応，九軸センサー内の温度センサーをつかって音速を校正しているが，逆に安定性を損なうようだったら，→board tempなのか…ならばつかえないのか）20℃1気圧とかで計算しておく．

### タイマー [Main.ino]

あらかじめ設定してあるタイマー（int Timer）(ms)と，millis()を比較する．
（millis()はプログラム開始からの時間をmsで返す）（<http://www.musashinodenpa.com/arduino/ref/index.php?f=0&pos=2524>）

## KiCad design kicad/DERC_CanSat_2022.kicad_pcb

Parts:
C1, C2, C5, C6, C7: 0.1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3, C4: 22p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C8, C9: (no value)
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D2, D3, D4: LED; LED_D3.0mm
IC1: NJM2845DL1-05-TE1; TO-252-2; Manufacturer_Part_Number NJM2845DL1-05-TE1
IC2, IC3: NJM78L33SU3; SOT-89-3; Manufacturer_Part_Number NJM78L33SU3
IC4, IC5: TB67H450FNG,EL; SOIC127P600X175-9N; Manufacturer_Part_Number TB67H450FNG,EL
J1, J2: Conn_01x02_Male; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J3: Nichrome_Conn_01x02_Male; TerminalBlock_Altech_AK300-2_P5.00mm
M1: Motor_DC_1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
M2: Motor_DC_2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q1: Q_NMOS_GDS; TO229P241X654X988-3P
R1, R2, R5: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4, R7, R8, R9, R10: 1; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6, R11, R12: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
S1: SS-22F06-G5-A; PowerSwitch; Manufacturer_Part_Number SS-22F06-G5-A
SW2: SW_DIP_x01; TVBP06B043CWB
U1: ATmega328P-P; DIP-28_W7.62mm
U2: HC-SR04
U3: GNSS
U4: SD
U5: AE-BNO055
U6: Writer; PinHeader_1x05_P2.54mm_Vertical
Y1: 16M; Crystal_HC49-4H_Vertical

Connections:
+3.3VA: IC3.2 (GND), IC4.4 (VREF), IC5.4 (VREF), R12.2
+3V3: IC2.2 (GND), R2.1
+5V: C2.1, C6.1, C7.1, C9.1, IC1.2 (VOUT), R1.2, R11.2, U1.7 (VCC), U1.20 (AVCC), U2.4 (VCC), U3.1 (5V), U4.1 (5V), U5.1 (VIN), U6.4 (VCC)
/BAT1: IC1.1 (VIN), IC2.1 (VOUT), S1.2 (COM_1)
/BAT2: C8.1, IC3.1 (VOUT), IC4.5 (VM), IC5.5 (VM), S1.5 (COM_2)
/BAT2_bSW: J1.1, J3.1, S1.6 (NO_2)
/M1_IN_LOW: IC4.3 (IN1), U1.11 (PD5)
/M1_IN_PWM: IC4.2 (IN2), U1.15 (PB1)
/M2_IN_LOW: IC5.3 (IN1), U1.12 (PD6)
/M2_IN_PWM: IC5.2 (IN2), U1.16 (PB2)
GND1: C1.1, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, D2.1 (K), D3.1 (K), D4.1 (K), IC1.3 (GND), IC2.3 (VIN), IC3.3 (VIN), IC4.1 (GND), IC5.1 (GND), J1.3 (Pin_2), J2.3 (Pin_2), Q1.3 (S), R3.2, R4.2, R5.1, R7.2, R8.2, R9.2, R10.2, SW2.2, U1.8 (GND), U1.22 (GND), U2.1 (GND), U3.2 (GND), U4.4 (GND), U5.2 (GND), U5.6, U6.5 (GND)
unnamed: C1.2, U1.21 (AREF)
unnamed: C3.1, U1.9 (XTAL1/PB6), Y1.2
unnamed: C4.1, U1.10 (XTAL2/PB7), Y1.1
unnamed: C5.1, R1.1, SW2.1, U1.1 (~RESET/PC6)
unnamed: C5.2, U6.1 (RESET)
unnamed: D1.1 (K), U3.4 (TXD)
unnamed: D1.2 (A), R2.2, U1.2 (PD0), U6.2 (RXD)
unnamed: D2.2 (A), R6.1
unnamed: D3.2 (A), R11.1
unnamed: D4.2 (A), R12.1
unnamed: IC4.6 (OUT1), M1.2 (-)
unnamed: IC4.7 (RS), R3.1, R7.1, R9.1
unnamed: IC4.8 (OUT2), M1.1 (+)
unnamed: IC5.6 (OUT1), M2.2 (-)
unnamed: IC5.7 (RS), R4.1, R8.1, R10.1
unnamed: IC5.8 (OUT2), M2.1 (+)
unnamed: J2.1, S1.3 (NO_1)
unnamed: J3.2, Q1.2 (D)
unnamed: Q1.1 (G), R5.2, U1.13 (PD7)
unnamed: R6.2, U1.6 (PD4)
unnamed: U1.3 (PD1), U3.3 (RXD), U6.3 (TXD)
unnamed: U1.4 (PD2), U2.2 (ECHO)
unnamed: U1.5 (PD3), U2.3 (TRIG)
unnamed: U1.14 (PB0), U4.8 (CS(SS))
unnamed: U1.17 (PB3), U4.7 (CMD(MOSI))
unnamed: U1.18 (PB4), U4.6 (DAT(MISO))
unnamed: U1.19 (PB5), U4.5 (CLK(SCL))
unnamed: U1.27 (PC4), U5.3 (SDA)
unnamed: U1.28 (PC5), U5.4 (SCL)

Notes on the sheet:
抵抗値で定電流制御の電流決めるため3本パラ

Board: 2 copper layers, 100.0 x 75.0 mm, 46 parts (1 on the bottom side), 40 nets.

Other parts of the board:
2022: LOGO; logotekina_25

## Commit log

2022-05-02 Update Readme.md
    いろいろ書き足した
2022-05-02 complete (I wish)
2022-05-03 add Distance, isMoving
2022-05-03 exclude vscode
2022-05-03 add more info
2022-05-03 add about main.ino
2022-05-03 re-mkdir
2022-05-03 debugged
2022-05-03 done! (may be)
2022-05-03 complete Motor.h
2022-05-03 write later...
2022-05-03 check the func works
2022-05-03 done wo/rotate
2022-05-03 .c 2 .cpp / .h 2 .hpp
2022-05-03 2 C++
2022-05-03 unify extentions (C++)
2022-05-05 no need for using hpp
2022-05-05 distinguish the meaning of "temperature"
2022-05-05 add comment
2022-05-05 change folder
2022-05-05 done! (fixed little clinker)
2022-05-05 done! (fixed/add some to meet w/ bno055)
2022-05-05 small fix of include
2022-05-05 small fix at include
2022-05-05 fixed small clinker
2022-05-05 changed dir (read ReadMe.lib.md)
2022-05-05 back to C++(cuz it's smarter)
2022-05-05 changed dir
2022-05-05 add i2c addr
2022-05-05 change include for flexibility
2022-05-05 move dir
2022-05-05 add for bunbackup
2022-05-05 add rotate
2022-05-05 add rotate(hope this works...)
2022-05-05 small change for separated lib
2022-05-05 small changes for meet w/ sep. lib
2022-05-05 fixed weird comment
2022-05-06 fixed to follow the MD rules
2022-05-06 fix fatal mistake
2022-05-06 missing semi-colon...
2022-05-06 add some to work this right
2022-05-06 does not work but...
2022-05-06 fixed some mistakes
2022-05-06 ニクロム線書きました
2022-05-06 small improve but...
2022-05-06 begin writing this
2022-05-06 add init for SD
2022-05-06 i was selfish
2022-05-09 complete SD Lib
2022-05-10 fixed small error
2022-05-10 fix 4 memory saving
2022-05-10 fix for MD lint
2022-05-13 flight pin
2022-05-15 add warning
2022-05-15 avoid C++ and some fix for mem
2022-05-15 fix for mem
2022-05-15 change file of RADPI
2022-05-15 fix for C
2022-05-15 complete GuideGPS! (I hope)
2022-05-15 using MATLAB to calc
2022-05-15 make this works for fixed lib
2022-05-16 adapt software serial
2022-05-16 fix small miss
2022-05-16 add mem check (723bytes free for now)
2022-05-16 small fix of GPS
2022-05-16 small fix for GPS
2022-05-17 fix for software serial
2022-05-17 fix small & fatal error
2022-05-17 add goal()
2022-05-18 add pinassign
2022-05-18 small fix
2022-05-18 fix gps pin
2022-05-19 add BNO055test
2022-05-19 done DistanceTest
2022-05-19 add testSerial
2022-05-19 using linear accel.
2022-05-19 add SDtest
2022-05-19 it works!
2022-05-19 make this work!
2022-05-22 solve unstable orientation
2022-05-22 motor rotates well!
2022-05-22 add PI
2022-05-22 this works!
2022-05-22 add test cases
2022-05-22 fix minor problems
2022-05-22 partly works very fine (and i got to sleep)
2022-05-22 add notes for 9 axis sensor
2022-05-25 add comments
2022-05-25 add small tests of Flight Pin and Nichrome
2022-05-25 add notes of Nichrome
2022-05-25 tiny fix of type
2022-05-25 make this works, but ...
2022-05-26 tryin' to log gps data
2022-06-01 try to avoid float
2022-06-03 ニクロム線関連
2022-06-08 gps guide wo/ float
2022-06-08 fix typo, merged from dev
2022-06-17 fixes for real Elizabeth
2022-06-17 flowchart for review
2022-06-19 add flowchart
2022-06-19 add log part
2022-06-19 huge improve at calc distance & orientation w/GPS
2022-06-19 apply effort of PlainC_gpscalc
2022-06-26 change log rate
2022-06-28 add landing test
2022-06-28 fix for real world
2022-06-28 add/fix for 審査書
2022-07-21 draw flow and fix 4 debug
2022-07-21 ram down memory
2022-07-28 anastasis Motor
2022-07-28 add backwardtest
2022-07-28 update around motor
2022-07-28 trying to fix the problem
2022-07-29 fix around "backward"
2022-07-29 fix comment
2022-08-06 add kicad data
2022-08-09 fix for noshiro!
2022-08-13 noshiro!
2022-08-13 Set theme jekyll-theme-cayman
